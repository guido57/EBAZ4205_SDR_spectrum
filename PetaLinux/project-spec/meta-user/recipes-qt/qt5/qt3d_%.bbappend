SRC_URI = "git://code.qt.io/qt/qt3d.git;name=qt3d;branch=5.15;protocol=git"

SRCREV = "92853c6e1aa95dfb7d605959ff44ccc124fbd62c"

