SRC_URI = "git://code.qt.io/qt/qtserialbus.git;name=qt3d;branch=5.15;protocol=git"

SRCREV = "d3394c81f10e5d5c40663e88e185335549e4bc12"

